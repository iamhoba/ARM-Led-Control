# Keil uVision project Led_Control.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Led_Control
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Mcal
    ./src/Mcal/IntrCtrl/Incl/: IntCtrl.h IntCtrl_Types.h
    ./src/Mcal/IntrCtrl/: IntCtrl.c
    ./src/Mcal/Port/: Port.c
    ./src/Mcal/Port/Incl/: Port.h
  group Common
    ./src/Common/Incl/: Mcu_HW.h Types.h
  group Config
    ./src/Config/Incl/: IntCtrl_Cfg.h Port_Cfg.h
    ./src/Config/: IntCtrl_Lcfg.c Port_Lcfg.c
  group Appl
    ./src/Appl/: main.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
